# Keil uVision project PrjCclNoOs.uvprojx, settings and files
target PrjCclNoOs (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PrjCclNoOs
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: adc.c dma.c rtc.c rng.c wwdg.c stm32f2xx_hal_timebase_TIM.c spi.c tim.c stm32f2xx_hal_msp.c stm32f2xx_it.c main.c iwdg.c i2c.c gpio.c can.c usart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_i2c.c stm32f2xx_hal_cortex.c stm32f2xx_hal_adc.c stm32f2xx_hal_rng.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rtc.c stm32f2xx_hal_dma.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_can.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_pwr.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_uart.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_spi.c
software components: CMSIS:CORE 4.1.0
