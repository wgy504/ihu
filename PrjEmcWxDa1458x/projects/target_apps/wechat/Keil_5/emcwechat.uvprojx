# Keil uVision project emcwechat.uvprojx, settings and files
target emcwx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta4
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: wechat +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt"
  c include: .\..\;.\..\..\..\..\sdk_580\sdk\platform\include;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\..\..\..\sdk_580\sdk\app_modules\api;.\..\..\..\..\sdk_580\sdk\app_modules\src\app_bass;.\..\..\..\..\sdk_580\sdk\app_modules\src\app_custs;.\..\..\..\..\sdk_580\sdk\app_modules\src\app_diss;.\..\..\..\..\sdk_580\sdk\app_modules\src\app_findme;.\..\..\..\..\sdk_580\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\sdk_580\sdk\app_modules\src\app_proxr;.\..\..\..\..\sdk_580\sdk\app_modules\src\app_spotar;.\..\..\..\..\sdk_580\sdk\ble_stack\controller\em;.\..\..\..\..\sdk_580\sdk\ble_stack\controller\llc;.\..\..\..\..\sdk_580\sdk\ble_stack\controller\lld;.\..\..\..\..\sdk_580\sdk\ble_stack\controller\llm;.\..\..\..\..\sdk_580\sdk\ble_stack\hcic;.\..\..\..\..\sdk_580\sdk\ble_stack\hcih;.\..\..\..\..\sdk_580\sdk\ble_stack\host\att;.\..\..\..\..\sdk_580\sdk\ble_stack\host\att\attc;.\..\..\..\..\sdk_580\sdk\ble_stack\host\att\attm;.\..\..\..\..\sdk_580\sdk\ble_stack\host\att\atts;.\..\..\..\..\sdk_580\sdk\ble_stack\host\gap;.\..\..\..\..\sdk_580\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\sdk_580\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\sdk_580\sdk\ble_stack\host\gatt;.\..\..\..\..\sdk_580\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\sdk_580\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\sdk_580\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\sdk_580\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\sdk_580\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\sdk_580\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\sdk_580\sdk\ble_stack\host\smp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\accel;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\adc_notify;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anc\ancc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anp\anpc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anp\anps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\bas\basc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\bas\bass;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\blp\blpc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\blp\blps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\blp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cpp\cppc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cpp\cpps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cpp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cscp\cscpc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cscp\cscps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cscp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\custom;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\custom\custs;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\device_config;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\dis\disc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\dis\diss;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\find\findl;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\find\findt;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\glp\glpc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\glp\glps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\glp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hogp\hogpbh;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hogp\hogpd;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hogp\hogprh;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hogp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hrp\hrpc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hrp\hrps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hrp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\htp\htpc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\htp\htpt;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\htp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\ieu;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\lan\lanc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\lan\lans;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\lan;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\mpu;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\pasp\paspc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\pasp\pasps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\pasp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\prox\proxm;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\prox\proxr;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\rscp\rscpc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\rscp\rscps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\rscp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\sample128;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\scpp\scppc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\scpp\scpps;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\scpp;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\spota\spotar;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\sps\sps_client;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\sps\sps_server;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\tip\tipc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\tip\tips;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\tip;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\uds\udss;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\uds;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wpt\wptc;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wpt\wpts;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wpt;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wss\wsss;.\..\..\..\..\sdk_580\sdk\ble_stack\rwble;.\..\..\..\..\sdk_580\sdk\ble_stack\rwble_hl;.\..\..\..\..\sdk_580\sdk\common_project_files;.\..\..\..\..\sdk_580\sdk\platform\arch;.\..\..\..\..\sdk_580\sdk\platform\arch\boot\rvds;.\..\..\..\..\sdk_580\sdk\platform\arch\compiler\rvds;.\..\..\..\..\sdk_580\sdk\platform\arch\ll\rvds;.\..\..\..\..\sdk_580\sdk\platform\arch\main;.\..\..\..\..\sdk_580\sdk\platform\arch;.\..\..\..\..\sdk_580\sdk\platform\core_modules\arch_console;.\..\..\..\..\sdk_580\sdk\platform\core_modules\common\api;.\..\..\..\..\sdk_580\sdk\platform\core_modules\crypto;.\..\..\..\..\sdk_580\sdk\platform\core_modules\dbg\api;.\..\..\..\..\sdk_580\sdk\platform\core_modules\gtl\src;.\..\..\..\..\sdk_580\sdk\platform\core_modules\ke\api;.\..\..\..\..\sdk_580\sdk\platform\core_modules\ke\src;.\..\..\..\..\sdk_580\sdk\platform\core_modules\nvds\api;.\..\..\..\..\sdk_580\sdk\platform\core_modules\rf\api;.\..\..\..\..\sdk_580\sdk\platform\core_modules\rwip\api;.\..\..\..\..\sdk_580\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\sdk_580\sdk\platform\driver\accel;.\..\..\..\..\sdk_580\sdk\platform\driver\adc;.\..\..\..\..\sdk_580\sdk\platform\driver\battery;.\..\..\..\..\sdk_580\sdk\platform\driver\bme280;.\..\..\..\..\sdk_580\sdk\platform\driver\coex;.\..\..\..\..\sdk_580\sdk\platform\driver\coex;.\..\..\..\..\sdk_580\sdk\platform\driver\emi;.\..\..\..\..\sdk_580\sdk\platform\driver\gpio;.\..\..\..\..\sdk_580\sdk\platform\driver\i2c_BMI055;.\..\..\..\..\sdk_580\sdk\platform\driver\i2c_core;.\..\..\..\..\sdk_580\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\sdk_580\sdk\platform\driver\intc;.\..\..\..\..\sdk_580\sdk\platform\driver\inv;.\..\..\..\..\sdk_580\sdk\platform\driver\led;.\..\..\..\..\sdk_580\sdk\platform\driver\mc3410;.\..\..\..\..\sdk_580\sdk\platform\driver\pwm;.\..\..\..\..\sdk_580\sdk\platform\driver\rc5;.\..\..\..\..\sdk_580\sdk\platform\driver\reg;.\..\..\..\..\sdk_580\sdk\platform\driver\sensor;.\..\..\..\..\sdk_580\sdk\platform\driver\spi;.\..\..\..\..\sdk_580\sdk\platform\driver\spi_439;.\..\..\..\..\sdk_580\sdk\platform\driver\spi_flash;.\..\..\..\..\sdk_580\sdk\platform\driver\spi_hci;.\..\..\..\..\sdk_580\sdk\platform\driver\syscntl;.\..\..\..\..\sdk_580\sdk\platform\driver\timer;.\..\..\..\..\sdk_580\sdk\platform\driver\trng;.\..\..\..\..\sdk_580\sdk\platform\driver\uart;.\..\..\..\..\sdk_580\sdk\platform\driver\wkupct_quadec;.\..\src\config;.\..\src;.\..\..\..\..\sdk_580\sdk\platform\core_modules\gtl\api;.\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wechat;..\src\common;..\src\products;.\..\..\..\..\sdk_580\sdk\app_modules\src\app_wechat;..\..\..\..\..\SrcBxxh;..\..\..\..\..\SrcBxxh\l0comvm;..\..\..\..\..\SrcBxxh\l0vmapi;..\..\..\..\..\SrcBxxh\l0vmda;..\..\..\..\..\SrcBxxh\l1service;..\..\..\..\..\SrcBxxh\l2frame;..\..\..\..\..\SrcBxxh\l2_asyapi_tc;..\..\..\..\..\SrcBxxh\l3emcwx;..\..\..\..\..\SrcBxxh\l2_asyapi_tc\crc32;..\..\..\..\..\SrcBxxh\l2_asyapi_tc\crypt;..\..\..\..\..\SrcBxxh\l2_asyapi_tc\example;..\..\..\..\..\SrcBxxh\l2_asyapi_tc\protobuf
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT5: ROM 0x21000 size 0x13f00
  memory RVCT9: RAM 0x20005100 size 0x5600
  memory RVCT10: RAM 0x8000 size 0x1000
  scatter file: .\..\..\..\..\sdk_580\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\sdk_580\sdk\common_project_files\misc\rom_symdef.txt  --symdefs=wechat_580_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../sdk_580/sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../../../../sdk_580/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../sdk_580/sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../../sdk_580/sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../../sdk_580/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_patch.c
    ./../../../../sdk_580/sdk/platform/driver/uart/: uart_ext_wkup.c
    ./../../../../sdk_580/sdk/platform/core_modules/wlan_coex/: wlan_coex.c
  group sdk_patches
    ./../../../../sdk_580/sdk/platform/patch_code/DA14580/obj/: atts_task.obj ch_map.obj gapm_util.obj ke_task.obj smpc.obj smpc_task.obj llc.obj
  group sdk_patches_581
    ./../../../../sdk_580/sdk/platform/patch_code/DA14581/obj/: atts_util.obj lld.obj llm_task.obj smpc_task.obj
  group sdk_driver
    ./../../../../sdk_580/sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../sdk_580/sdk/platform/driver/gpio/: gpio.c
    ./../../../../sdk_580/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../../sdk_580/sdk/platform/driver/battery/: battery.c
    ./../../../../sdk_580/sdk/platform/driver/adc/: adc.c
    ./../../../../sdk_580/sdk/platform/driver/trng/: trng.c
    ./../../../../sdk_580/sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../../sdk_580/sdk/platform/driver/spi/: spi.c
    ./../../../../sdk_580/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ./../../../../sdk_580/sdk/platform/driver/pwm/: pwm.c
    ./../../../../sdk_580/sdk/platform/driver/uart/: uart2.c
    ./../../../../sdk_580/sdk/platform/driver/systick/: systick.c
  group sdk_ble
    ./../../../../sdk_580/sdk/platform/core_modules/rf/src/: rf_580.c
    ./../../../../sdk_580/sdk/ble_stack/rwble/: rwble.c
    ./../../../../sdk_580/sdk/platform/core_modules/rwip/src/: rwip.c
    ./../../../../sdk_580/sdk/ble_stack/host/gap/gapm/: gapm.c
  group sdk_profiles
    ./../../../../sdk_580/sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/accel/: accel.c accel_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/bas/basc/: basc.c basc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/bas/bass/: bass.c bass_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/blp/blpc/: blpc.c blpc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/blp/blps/: blps.c blps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/dis/disc/: disc.c disc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/dis/diss/: diss.c diss_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/find/findt/: findt.c findt_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/hogp/hogpbh/: hogpbh.c hogpbh_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/hogp/hogpd/: hogpd.c hogpd_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/hogp/hogprh/: hogprh.c hogprh_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/hrp/hrpc/: hrpc.c hrpc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/hrp/hrps/: hrps.c hrps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/htp/htpc/: htpc.c htpc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/htp/htpt/: htpt.c htpt_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/prox/proxm/: proxm.c proxm_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/prox/proxr/: proxr.c proxr_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/scpp/scppc/: scppc.c scppc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/scpp/scpps/: scpps.c scpps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/: prf_utils.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/anp/anpc/: anpc.c anpc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/anp/anps/: anps.c anps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/cscp/cscpc/: cscpc.c cscpc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/cscp/cscps/: cscps.c cscps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/glp/glpc/: glpc.c glpc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/glp/glps/: glps.c glps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/pasp/paspc/: paspc.c paspc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/pasp/pasps/: pasps.c pasps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/rscp/rscpc/: rscpc.c rscpc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/rscp/rscps/: rscps.c rscps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/tip/tipc/: tipc.c tipc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/tip/tips/: tips.c tips_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/find/findl/: findl.c findl_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/cpp/cppc/: cppc.c cppc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/cpp/cpps/: cpps.c cpps_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/lan/lanc/: lanc.c lanc_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/lan/lans/: lans.c lans_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/spota/spotar/: spotar.c spotar_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/custom/: custom_common.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/custom/custs/: custs1.c custs1_task.c custs2.c custs2_task.c
    ./../../../../sdk_580/sdk/ble_stack/profiles/wechat/: wechat.c wechat_task.c
  group sdk_app
    ./../../../../sdk_580/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../../sdk_580/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c
    ./../../../../sdk_580/sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../../../../sdk_580/sdk/app_modules/src/app_easy/: app_easy_timer.c app_easy_msg_utils.c app_easy_security.c
    ./../../../../sdk_580/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    ./../../../../sdk_580/sdk/app_modules/src/app_wechat/: app_wechat.c app_wechat_task.c
    ./../../../../sdk_580/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
  group sdk_driver_api
    ./../../../../sdk_580/sdk/platform/driver/adc/: adc.h
    ./../../../../sdk_580/sdk/platform/driver/battery/: battery.h
    ./../../../../sdk_580/sdk/platform/driver/gpio/: gpio.h
    ./../../../../sdk_580/sdk/platform/driver/i2c_core/: i2c_core.h
    ./../../../../sdk_580/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ./../../../../sdk_580/sdk/platform/driver/pwm/: pwm.h
    ./../../../../sdk_580/sdk/platform/driver/spi/: spi.h
    ./../../../../sdk_580/sdk/platform/driver/spi_flash/: spi_flash.h
    ./../../../../sdk_580/sdk/platform/driver/trng/: trng.h
    ./../../../../sdk_580/sdk/platform/driver/uart/: uart.h
    ./../../../../sdk_580/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
    ./../../../../sdk_580/sdk/platform/driver/systick/: systick.h
  group sdk_api
    ./../../../../sdk_580/sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_task.h app_user_config.h app_easy_security.h app_security.h
    ./../../../../sdk_580/sdk/platform/arch/: arch_api.h
    ./../../../../sdk_580/sdk/platform/arch/main/: arch_wdg.h
  group user_config
    ./../src/config/: user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h user_config_sw_ver.h da1458x_config_advanced.h da1458x_config_basic.h
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_wechat.c
    ../src/common/: ble_wechat_util.c crc32.c epb.c epb_MmBp.c md5.c wecaht_aes.c
    ../src/products/: mpbledemo2.c mpbledemo2.h
  group l0comvm
    ../../../../../SrcBxxh/l0comvm/: commsg.h comtype.h sysconfig.h sysdim.h sysengpar.h sysversion.h vmlayer.c vmlayer.h readme.txt
  group l0vmapi
    ../../../../../SrcBxxh/l0vmapi/: i2c_led.c i2c_led.h
  group l0vmda
    ../../../../../SrcBxxh/l0vmda/: vmdashell_task.c vmdashell_task.h
  group l1service
    ../../../../../SrcBxxh/l1service/: l1comdef.h l1timer.c l1timer.h
  group l2_asyapi_tc
    ../../../../../SrcBxxh/l2_asyapi_tc/crypt/aes/: aes.h aes_cbc.c aes_core.c aes_locl.h cbc128.c modes.h
    ../../../../../SrcBxxh/l2_asyapi_tc/crypt/: aes_crypt.c aes_crypt.h
  group l2frame
    ../../../../../SrcBxxh/l2frame/: l2adcaries.c l2adcaries.h l2aksleo.c l2aksleo.h l2asylibra.c l2asylibra.h
  group l3emcwx
    ../../../../../SrcBxxh/l3emcwx/: l3emc.c l3emc.h
