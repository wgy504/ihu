# Keil uVision project PrjCclFo@207VG.uvprojx, settings and files
target PrjCclFo@207VG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PrjCclFo@207VG +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;                                                               ../Drivers/STM32F2xx_HAL_Driver/Inc;                                                               ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;                                                               ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                                                               ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;                                                               ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                               ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                               ../Drivers/CMSIS/Include;                                                               ..\..\SrcBxxh\l0bsp_stm32;                                                               ..\..\SrcBxxh\l0commsgccl;                                                               ..\..\SrcBxxh\l0comvm;                                                               ..\..\SrcBxxh\l1vmfreeos;                                                               ..\..\SrcBxxh\l2framefreeos;                                                               ..\..\SrcBxxh\l3applccl
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_flash_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rtc.c stm32f2xx_hal_spi.c stm32f2xx_hal_rcc.c stm32f2xx_hal_adc.c stm32f2xx_hal.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_uart.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c timers.c queue.c event_groups.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: main.c stm32f2xx_hal_timebase_TIM.c usart.c rtc.c i2c.c adc.c stm32f2xx_hal_msp.c spi.c gpio.c stm32f2xx_it.c freertos.c usb_otg.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group L0bsp_stm32
    ../../SrcBxxh/l0bsp_stm32/: bsp_adc.c bsp_adc.h bsp_led.c bsp_led.h bsp_usart.c bsp_usart.h bsp_i2c.c bsp_i2c.h bsp_dido.c bsp_dido.h bsp_calendar.c bsp_calendar.h bsp_rtc.c bsp_rtc.h bsp_cpuid.c bsp_cpuid.h bsp_stmflash.c bsp_stmflash.h bsp_spi.c bsp_spi.h bsp_pwr_sav.c bsp_pwr_sav.h
  group L0comvm
    ../../SrcBxxh/l0commsgccl/: commsgccl.h
    ../../SrcBxxh/l0comvm/: comtype.h sysconfig.h sysdim.h sysengpar.h sysversion.h readme.txt
  group L1vmfo
    ../../SrcBxxh/l1vmfreeos/: l1comdef_freeos.h l1timer_freeos.c l1timer_freeos.h vmfreeoslayer.c vmfreeoslayer.h l1vmfo.c l1vmfo.h vmmw_ble.c vmmw_ble.h vmmw_gprs.c vmmw_gprs.h vmmw_rfid.c vmmw_rfid.h vmmw_navig.c vmmw_navig.h vmmw_pcf8563.c vmmw_pcf8563.h vmmw_cam.c vmmw_cam.h
  group L2frame
    ../../SrcBxxh/l2framefreeos/: huitp.h huixmlcodec.c huixmlcodec.h l2adclibra.c l2adclibra.h l2didocap.c l2didocap.h l2i2caries.c l2i2caries.h l2ledpisces.c l2ledpisces.h l2spsvirgo.c l2spsvirgo.h l2dcmiaris.c l2dcmiaris.h
  group L3appl
    ../../SrcBxxh/l3applccl/: l3ccl.c l3ccl.h
software components: CMSIS:CORE 4.1.0
