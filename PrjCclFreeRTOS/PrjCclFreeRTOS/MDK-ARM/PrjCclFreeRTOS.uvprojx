# Keil uVision project PrjCclFreeRTOS.uvprojx, settings and files
target PrjCclFreeRTOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PrjCclFreeRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Application/User
    ../Src/: tim.c adc.c wwdg.c i2c.c stm32f2xx_hal_timebase_TIM.c stm32f2xx_it.c gpio.c rtc.c freertos.c main.c stm32f2xx_hal_msp.c iwdg.c usart.c spi.c rng.c can.c dma.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c croutine.c queue.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_dma.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_i2c.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_adc.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_rng.c stm32f2xx_hal_uart.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_can.c stm32f2xx_hal.c stm32f2xx_hal_flash.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_rtc.c stm32f2xx_hal_gpio.c
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
software components: CMSIS:CORE 4.1.0
