# Keil uVision project uart2_async.uvproj, settings and files
target uart2_async (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uart2_async +hex
  c flags: Optim=1 wLevel=2
  c misc: --c99 --thumb -c
  c include: ..\include;..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\sdk\platform\include;..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\sdk\ble_stack\rwble_hl\rwble_hl;..\..\..\..\..\sdk\platform\driver\uart
  library: MicroLIB
  scatter file: ..\..\shared\peripheral_examples.sct
  group boot
    ../../shared/startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c
  group driver
    ../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../sdk/platform/driver/uart/: uart2.c
  group app
    ../src/: main.c uart2_write_test.c uart2_read_test.c uart2_loopback_test.c ring_buffer.c uart2_print_string.c user_periph_setup.c
