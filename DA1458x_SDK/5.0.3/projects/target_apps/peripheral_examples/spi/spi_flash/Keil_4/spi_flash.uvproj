# Keil uVision project spi_flash.uvproj, settings and files
target spi_flash (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: spi_flash +hex
  c flags: Optim=1 wLevel=2
  c misc: --c99 --thumb -c
  c include: ..\include;..\..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\..\sdk\platform\include;..\..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\..\sdk\platform\driver\spi_flash;..\..\..\..\..\..\sdk\platform\driver\spi;..\..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\..\sdk\ble_stack\rwble_hl\rwble_hl;..\..\..\shared\common_uart;..\..\..\..\..\..\sdk\platform\driver\uart
  library: MicroLIB
  scatter file: ..\..\..\shared\peripheral_examples.sct
  group boot
    ../../../shared/startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c
  group driver
    ../../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../../../../../sdk/platform/driver/spi/: spi.c
    ../../../../../../sdk/platform/driver/uart/: uart2.c
  group common_uart
    ../../../shared/common_uart/: common_uart.c
  group app
    ../src/: main.c user_periph_setup.c
