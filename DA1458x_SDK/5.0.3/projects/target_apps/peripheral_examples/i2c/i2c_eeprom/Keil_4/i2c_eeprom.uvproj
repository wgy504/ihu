# Keil uVision project i2c_eeprom.uvproj, settings and files
target i2c_eeprom (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: i2c_eeprom +hex
  c flags: Optim=1 wLevel=2
  c misc: --c99 --thumb -c
  c include: ..\include;..\..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\..\sdk\platform\include;..\..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;..\..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\..\sdk\ble_stack\rwble_hl\rwble_hl;..\..\..\shared\common_uart;..\..\..\..\..\..\sdk\platform\driver\uart
  library: MicroLIB
  scatter file: ..\..\..\shared\peripheral_examples.sct
  group boot
    ../../../shared/startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c
  group driver
    ../../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../../../../sdk/platform/driver/uart/: uart2.c
  group common_uart
    ../../../shared/common_uart/: common_uart.c
  group app
    ../src/: main.c user_periph_setup.c
