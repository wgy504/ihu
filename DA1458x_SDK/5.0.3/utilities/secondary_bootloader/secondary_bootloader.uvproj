# Keil uVision project secondary_bootloader.uvproj, settings and files
target secondary_bootloader (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: secondary_bootloader +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: .\includes;..\..\sdk\platform\include;..\..\sdk\platform\driver\spi;..\..\sdk\platform\driver\i2c_eeprom;..\..\sdk\platform\driver\spi_flash;..\..\sdk\platform\driver\gpio;..\..\sdk\platform\arch;..\..\sdk\platform\arch\compiler\rvds;..\..\sdk\platform\arch\ll\rvds;..\..\sdk\platform\driver\reg
  asm include: .\includes
  library: MicroLIB
  scatter file: .\startup\bootloader.sct
  group boot
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group src
    ./src/: bootloader.c timer.c uart.c main.c uart_booter.c spi_commands.c crc32.c sw_aes.c
    ../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../sdk/platform/driver/spi/: spi.c
    ../../sdk/platform/driver/gpio/: gpio.c
    ../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
  group includes
    ./includes/: user_periph_setup.h timer.h uart.h uart_booter.h bootloader.h spi_commands.h os_int.h os_port.h sw_aes.h
    ../../sdk/platform/include/: datasheet.h global_io.h
    ../../sdk/platform/driver/spi/: spi.h
    ../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../sdk/platform/driver/gpio/: gpio.h
    ../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
