# Keil uVision project stm32_test.uvproj, settings and files
target stm32test (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: RTC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STM322xG_EVAL, STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\StartUp;..\HardDrivers;..\STM32F20X_Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group StartUp
    ../StartUp/: startup_stm32f2xx.s system_stm32f2xx.c
  group App
    ../App/: main.c
  group HardDrivers
    ../HardDrivers/: led.c key.c rtc.c spi_flash.c
  group STM32F20X_Lib
    ../STM32F20X_Lib/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
