# Keil uVision project PrjBfscFo@207VC.uvprojx, settings and files
target PrjBfscFo@207VC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PrjBfscFo@207VC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;         ../Drivers/STM32F2xx_HAL_Driver/Inc;         ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;         ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;         ../Middlewares/Third_Party/FreeRTOS/Source/include;         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;         ../Drivers/CMSIS/Include;         ..\..\SrcBxxh\l0bsp_stm32;         ..\..\SrcBxxh\l0commsgbfsc;         ..\..\SrcBxxh\l0comvm;         ..\..\SrcBxxh\l1vmfreeos;         ..\..\SrcBxxh\l2framefreeos;         ..\..\SrcBxxh\l3applbfsc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c croutine.c tasks.c queue.c event_groups.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal.c stm32f2xx_hal_spi.c stm32f2xx_hal_pwr.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_adc.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_uart.c stm32f2xx_hal_can.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_crc.c stm32f2xx_hal_dac.c stm32f2xx_hal_i2c.c
  group Application/User
    ../Src/: main.c stm32f2xx_hal_msp.c freertos.c stm32f2xx_hal_timebase_TIM.c stm32f2xx_it.c
  group L0bsp_stm32
    ../../SrcBxxh/l0bsp_stm32/: bsp_adc.c bsp_adc.h bsp_led.c bsp_led.h bsp_spi.c bsp_spi.h bsp_tim.c bsp_tim.h bsp_usart.c bsp_usart.h bsp_i2c.c bsp_i2c.h bsp_dido.c bsp_dido.h bsp_can.c bsp_can.h bsp_crc.c bsp_crc.h bsp_wdog.c bsp_wdog.h bsp_calendar.c bsp_calendar.h bsp_rtc.c bsp_rtc.h bsp_cpuid.c bsp_cpuid.h
  group L0comvm
    ../../SrcBxxh/l0commsgbfsc/: commsgbfsc.h
    ../../SrcBxxh/l0comvm/: comtype.h sysconfig.h sysdim.h sysengpar.h sysversion.h readme.txt
  group L1vmfo
    ../../SrcBxxh/l1vmfreeos/: l1comdef_freeos.h l1timer_freeos.c l1timer_freeos.h vmfreeoslayer.c vmfreeoslayer.h l1vmfo.c l1vmfo.h vmmw_gprs.c vmmw_gprs.h
  group L2frame
    ../../SrcBxxh/l2framefreeos/: l2adclibra.c l2adclibra.h l2didocap.c l2didocap.h l2i2caries.c l2i2caries.h l2ledpisces.c l2ledpisces.h l2pwmtaurus.c l2pwmtaurus.h l2spileo.c l2spileo.h l2spsvirgo.c l2spsvirgo.h l2canvela.c l2canvela.h
  group L3appl
    ../../SrcBxxh/l3applbfsc/: l3bfsc.c l3bfsc.h
software components: CMSIS:CORE 4.1.0
