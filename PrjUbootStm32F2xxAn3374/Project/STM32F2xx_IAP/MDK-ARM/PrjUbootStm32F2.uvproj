# Keil uVision project PrjUbootStm32F2.uvproj, settings and files
target STM322xG_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,STM32F2XX
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../src/: ymodem.c common.c flash_if.c main.c menu.c stm32f2xx_it.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_usart.c
    ../../../LIBRARIES/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_dma.c stm32f2xx_i2c.c stm32f2xx_sdio.c
  group CMSIS
    ../src/: system_stm32f2xx.c
    ../../../LIBRARIES/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ./: startup_stm32f2xx.s
