# Keil uVision project PrjCclFo@207VC.uvprojx, settings and files
target PrjCclFo@207VC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PrjCclFo@207VC
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F2xx_HAL_Driver/Inc;   ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;   ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;   ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;   ../Drivers/CMSIS/Include;   ..\..\SrcBxxh\l0bsp_stm32;   ..\..\SrcBxxh\l0commsgccl;   ..\..\SrcBxxh\l0comvm;   ..\..\SrcBxxh\l1vmfreeos;   ..\..\SrcBxxh\l2framefreeos;   ..\..\SrcBxxh\l3applccl
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_dma.c stm32f2xx_hal_spi.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_adc.c stm32f2xx_hal_rcc.c stm32f2xx_hal.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_uart.c stm32f2xx_hal_tim.c stm32f2xx_hal_can.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_rtc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c timers.c queue.c event_groups.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: stm32f2xx_hal_msp.c main.c freertos.c stm32f2xx_it.c stm32f2xx_hal_timebase_TIM.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group L0bsp_stm32
    ../../SrcBxxh/l0bsp_stm32/: bsp_adc.c bsp_adc.h bsp_key.c bsp_key.h bsp_led.c bsp_led.h bsp_rs485.c bsp_rs485.h bsp_spi.c bsp_spi.h bsp_tim.c bsp_tim.h bsp_usart.c bsp_usart.h bsp_i2c.c bsp_i2c.h bsp_dido.c bsp_dido.h bsp_can.c bsp_can.h
  group L0comvm
    ../../SrcBxxh/l0commsgccl/: commsgccl.h
    ../../SrcBxxh/l0comvm/: comtype.h sysconfig.h sysdim.h sysengpar.h sysversion.h readme.txt
  group L1vmfo
    ../../SrcBxxh/l1vmfreeos/: l1comdef_freeos.h l1timer_freeos.c l1timer_freeos.h mod_hal_gprs.c mod_hal_gprs.h vmfreeoslayer.c vmfreeoslayer.h mod_hal_ble.c mod_hal_ble.h mod_hal_rfid.c mod_hal_rfid.h l1vmfo.c l1vmfo.h
  group L2frame
    ../../SrcBxxh/l2framefreeos/: huitp.h huixmlcodec.h huixmlcodec.c l2adclibra.c l2adclibra.h l2didocap.c l2didocap.h l2ethorion.c l2ethorion.h l2i2caries.c l2i2caries.h l2ledpisces.c l2ledpisces.h l2spileo.c l2spileo.h l2spsvirgo.c l2spsvirgo.h l2canvela.c l2canvela.h l2dcmiaris.c l2dcmiaris.h
  group L3appl
    ../../SrcBxxh/l3applccl/: l3ccl.c l3ccl.h
software components: CMSIS:CORE 4.1.0
