# Keil uVision project Project.uvproj, settings and files
target STM322xG_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL
  c include: ..\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F2x7_ETH_Driver\inc;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone;..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\portable\EWARM\ARM_CM3;..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../src/: system_stm32f2xx.c
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ./: startup_stm32f2xx.s
  group User
    ../src/: tftpserver.c flash_if.c httpserver.c main.c netconf.c stm32f2x7_eth_bsp.c stm32f2xx_it.c
  group LwIP
    ../../Utilities/Third_Party/lwip_v1.3.2/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_usart.c misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c
  group STM32F2x7_ETH_Driver
    ../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM322xG_EVAL
    ../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c stm322xg_eval.c
