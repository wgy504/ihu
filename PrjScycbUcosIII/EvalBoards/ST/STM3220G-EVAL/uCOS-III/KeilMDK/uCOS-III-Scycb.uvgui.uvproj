# Keil uVision project uCOS-III-Scycb.uvgui.uvproj, settings and files
target uCOS-III Scycb (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: uCOS-III +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\uCOS-III;..\..\uCOS-III\KeilMDK;..\..\BSP\OS\uCOS-III;..\..\BSP\STM32F2xx\inc;..\..\BSP\CMSIS\Device_Support;..\..\BSP\CMSIS;..\..\BSP\KeilMDK;..\..\BSP;..\..\..\..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uCOS-III\Source;..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\..\SrcBxxh\l0commsgscbcb;..\..\..\..\..\..\SrcBxxh\l0comvm;..\..\..\..\..\..\SrcBxxh\l0comvmuo;..\..\..\..\..\..\SrcBxxh\l1hd_stm32f2;..\..\..\..\..\..\SrcBxxh\l1vmucos;..\..\..\..\..\..\SrcBxxh\l2frameucos;..\..\..\..\..\..\SrcBxxh\l3appscycb
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./: app_cfg.h lib_cfg.h
    ../: app.c cpu_cfg.h includes.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_ioe.c bsp_ioe.h bsp_lcd.c bsp_lcd.h bsp_ser.c bsp_ser.h
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
    ../../BSP/KeilMDK/: cstartup.s
  group STM32F2xx Library
    ../../BSP/STM32F2xx/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
    ../../BSP/STM32F2xx/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group uC-LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC-CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uCOS-III Ports
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS-III Source
    ../../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group l0comvm
    ../../../../../../SrcBxxh/l0commsgscbcb/: commsgscycb.h
    ../../../../../../SrcBxxh/l0comvm/: comtype.h sysconfig.h sysdim.h sysengpar.h sysversion.h readme.txt
  group l1hd_stm32f2
    ../../../../../../SrcBxxh/l1hd_stm32f2/: key.c key.h led.c led.h rtc.c rtc.h spi_flash.c spi_flash.h spi_itf.c spi_itf.h usart.c usart.h timer.c timer.h
  group l1vmucos
    ../../../../../../SrcBxxh/l1vmucos/: l1comdef_ucos.h l1timer_ucos.c l1timer_ucos.h vmucoslayer.c vmucoslayer.h
  group l2frame
    ../../../../../../SrcBxxh/l2frameucos/: l2adclibra.c l2adclibra.h l2didocap.c l2didocap.h l2ethorion.c l2ethorion.h l2gpiocancer.c l2gpiocancer.h l2i2caries.c l2i2caries.h l2ledpisces.c l2ledpisces.h l2pwmtaurus.c l2pwmtaurus.h l2spileo.c l2spileo.h l2spsvirgo.c l2spsvirgo.h
  group l3scycb
    ../../../../../../SrcBxxh/l3appscycb/: l3scycb.c l3scycb.h
