# IAR project uCOS-III.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\uCOS-III; ..\..\BSP; ..\..\BSP\OS\uCOS-III; ..\..\BSP\CMSIS; ..\..\BSP\CMSIS\Device_Support; ..\..\BSP\STM32F2xx\inc; ..\..\BSP\IAR; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\..\..\..\..\uCOS-III\Source; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../: app.c cpu_cfg.h includes.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
    ./: app_cfg.h lib_cfg.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_ioe.c bsp_ioe.h bsp_lcd.c bsp_lcd.h bsp_ser.c bsp_ser.h
    ../../BSP/IAR/: cstartup.c stm32f2xx_flash.icf
  group BSP/CMSIS
    ../../BSP/CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group BSP/CMSIS/Device Support
    ../../BSP/CMSIS/Device_Support/: stm32f2xx.h stm32f2xx_conf.h system_stm32f2xx.c system_stm32f2xx.h
  group BSP/OS
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group BSP/STM32F2xx/inc
    ../../BSP/STM32F2xx/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
  group BSP/STM32F2xx/src
    ../../BSP/STM32F2xx/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group uC-CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/ARM-Cortex-M3/IAR
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC-LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/Ports/ARM-Cortex-M3/IAR
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-III/Source
    ../../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
